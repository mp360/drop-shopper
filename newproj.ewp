# IAR project newproj.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: newproj.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    IAR Nano Processor Proj 1/Nano/: BroadcastPacketSim.c HostCommandManager.c I2C.c main.c sensor.c
  group include
    IAR Nano Processor Proj 1/Nano/Include/: BroadcastPacketSim.h BuildConfig.h HostCommandManager.h I2C.h main.h Portable.h sensor.h
